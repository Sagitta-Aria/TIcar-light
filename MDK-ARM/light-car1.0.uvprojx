# Keil uVision project light-car1.0.uvprojx, settings and files
target light-car1.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IROM(0x00000000,0x00020000) IRAM(0x20200000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(80000000) ELITTLE
  output: light_car1_0 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MSPM0G3507__;CONFIG_MSPM0G3507;CONFIG_MSPM0G350X
  c misc: --diag_suppress=1,66
  c include: ..\app;..\hardware;..\system;..\config;..\generated;D:\Ti\mspm0_sdk_2_10_00_04\source;D:\Ti\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include
  asm include: D:\Ti\mspm0_sdk_2_10_00_04\source;D:\Ti\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20200000 size 0x8000
  group Startup
    ./: startup_mspm0g350x_uvision.s
  group app
    ../app/: main.c app.c motion.c menu.c tracking.c tracking_exception.c state_machine.c motor_test.c route.c speed_control.c app.h motion.h menu.h tracking.h tracking_exception.h state_machine.h motor_test.h route.h speed_control.h
  group hardware
    ../hardware/: motor.c gray.c encoder.c key.c link.c jy61p.c jq8400.c oled.c motor.h gray.h encoder.h key.h link.h jy61p.h jq8400.h oled.h oledfont.h
  group system
    ../system/: board.c delay.c interrupt.c board.h delay.h interrupt.h
  group config
    ../config/: board_config.h pin_map.h
  group generated
    ../generated/: ti_msp_dl_config.c ti_msp_dl_config.h
  group DriverLib
    D:/Ti/mspm0_sdk_2_10_00_04/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
  group doc
    ../: README.md
    ../doc/: PINMAP.md
